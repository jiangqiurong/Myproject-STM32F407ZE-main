# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\LCD;.\;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\DHT;..\HARDWARE\MAX30102;..\HARDWARE\BLE;..\HARDWARE\MPU6050;..\HARDWARE\PICTIME;..\HARDWARE\EEPROM;..\HARDWARE\KEYBOARD;..\HARDWARE\PAJ7620U2;..\HARDWARE\ASRPRO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c menu.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: tft.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT/: dht11.c
    ../HARDWARE/MAX30102/: algorithm.c i2c.c max30102.c
    ../HARDWARE/BLE/: ble.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../HARDWARE/PICTIME/: pictime.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../HARDWARE/ASRPRO/: asrpro.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_spi.c misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_syscfg.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
  group PIC
    ../HARDWARE/LCD/: pic_success.c pic_red_flag.c pic_camera.c pic_date.c pic_faceid.c pic_logo.c pic_pulse.c pic_rfid.c pic_touchid.c pic_temp_humi.c pic_storage.c pic_battery.c pic_ble.c pic.h pic_light.c pic_time.c pic_temperature.c pic_humidity.c pic_home.c pic_alarm_32x32.c pic_ble_32x32.c pic_alarm.c pic_sport.c pic_revdate_48x48.c pic_step_48x48.c pic_fail.c pic_auto_48x48.c pic_password_48x48.c pic_modify_48x48.c pic_fail_48x48.c pic_hand_48x48.c
